# Keil uVision project ossw-firmware-s120.uvprojx, settings and files
target nrf51822_xxaa_s120 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ossw-firmware-s120 +hex
  c flags: Optim=4 uC99=1
  c define: BLE_DFU_APP_SUPPORT BLE_STACK_SUPPORT_REQD S110 AMX_ANSIONLY BOARD_CUSTOM SOFTDEVICE_PRESENT NRF51
  c include: ..\sdk_mod
  library: MicroLIB
  memory RVCT4: ROM 0x1d000 size 0x1f000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group Application
    ../: main.c board.h
  group Screens
    ../screens/: scr_changedate.h scr_changedate.c scr_changetime.h scr_changetime.c scr_watchface.h scr_watchface.c scr_choosemode.h scr_choosemode.c scr_settings.c scr_settings.h scr_watchset.c scr_watchset.h scr_alert_notification.c scr_alert_notification.h scr_notifications.c scr_notifications.h
  group Libraries
    ../: scr_controls.c scr_controls.h ext_flash.c ext_flash.h mlcd.c mlcd.h spi.c spi.h ext_ram.c ext_ram.h mlcd_draw.c mlcd_draw.h rtc.c rtc.h buttons.c buttons.h scr_mngr.c scr_mngr.h utf8.c utf8.h battery.c battery.h vibration.c vibration.h notifications.c notifications.h
  group PAWN
    ../pawn/: osdefs.h amx.c amx.h amxext.c amxext.h amxutil.c amxutil.h
  group Fonts
    ../fonts/: font.h small_regular.h small_bold.h normal_regular.h normal_bold.h big_regular.h option_normal.h option_big.h
  group BLE
    ../ble/: ble_ossw.c ble_ossw.h ble_central.c ble_central.h ble_peripheral.c ble_peripheral.h
  group SDK Modifications
    ../sdk_mod/: device_manager_mixed.c device_manager.h
  group i18n
    ../i18n/: i18n.c i18n.h messages_en.h
software components: CMSIS:CORE 3.40.0, Device:Startup 7.2.1, nRF_BLE:BLE_Modules:ble_advdata 2.0.0, nRF_BLE:BLE_Modules:ble_advertising 2.0.0, nRF_BLE:BLE_Modules:ble_common 2.0.0, nRF_BLE:BLE_Modules:ble_conn_params 2.0.0, nRF_BLE:BLE_Modules:ble_date_time 2.0.0, nRF_BLE:BLE_Modules:ble_db_discovery 2.0.0, nRF_BLE:BLE_Modules:ble_service_common 2.0.0, nRF_BLE:BLE_Services:ble_bas 2.0.0, nRF_BLE:BLE_Services:ble_bas_c 2.0.0, nRF_BLE:BLE_Services:ble_dfu 2.0.0, nRF_BLE:BLE_Services:ble_dis 2.0.0, nRF_BLE:BLE_Services:ble_hrs_c 2.0.0, nRF_Drivers:app_uart 2.0.0, nRF_Drivers:nrf_adc 2.0.0, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:pstorage 2.0.0, nRF_Libraries:DFU:dfu_app_handler 2.0.0, nRF_Libraries:DFU:dfu_bootloader_util 2.0.0, nRF_Libraries:app_button 2.0.0, nRF_Libraries:app_error 2.0.0, nRF_Libraries:app_fifo 2.0.0, nRF_Libraries:app_gpiote 2.0.0, nRF_Libraries:app_timer 2.0.0, nRF_Libraries:app_trace 2.0.0, nRF_Libraries:app_util 2.0.0, nRF_Libraries:nrf_assert 2.0.0, nRF_Libraries:retarget 2.0.0, nRF_Libraries:sensorsim 2.0.0, nRF_SoftDevice:Internal:sd_common 1.1.2, nRF_SoftDevice:Internal:softdevice_present 1.1.2, nRF_SoftDevice:s120 2.0.0
